Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 4ee71998-7a6e-489f-a289-5877b0e1d862, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 54642207(2026).ifc
Time: 2025-11-19T22:00:19+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_32622_1
InPort_32622_2

# IfcFlowController: 54642207(2026):54642207 Bidet faucet, 54642207(2026):54642207 Bidet faucet:32622
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 54642207(2026); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 54642207; Name: 54642207 Bidet faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 200 x 50 x 170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 126.4 mm; NominalHeight: 157.7 mm; NominalWidth: 50 mm
Type - General - Author: BIMStone; BIMObjectName: 54642207(2026); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 2025/10/01
Type - Green Building Properties - URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/54642207; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/54642207
Type - Identity Data - Catalog Drawing URL: http://static.hansa.com/catdrw/54642207; Category B2C: Bidet; Color variants: 5464220733;5464220780;5464220781; Dimension Drawing URL: http://static.hansa.com/dimdrw/54642207; FDV Document URL: http://www.hansa.com/datasheet/54642207/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/54642207; Group: Bidet faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/54642207; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;International;Italy;Netherlands;Poland; Mobile Product Information URL: http://mpi.hansa.com/54642207; Model: 54642207 Bidet faucet; Name_en: 54642207 Bidet faucet; OmniClass Number: 23.31.23.00; OmniClass Title: Bidets; Product Code: 54642207; Product Family: HANSAVANTIS Style; Product Image URL: http://static.hansa.com/image/54642207; Product URL: http://static.hansa.com/54642207; Replacement to: 54632207; Spare-Part Information URL: http://static.hansa.com/sp/54642207; Technical DataSheet URL: http://www.hansa.com/datasheet/54642207/en; Type Name: 54642207 Bidet faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations;Ball joint; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.1 dm3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 C; Mechanical Parts: ø 30 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Spout Projection: 101 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 54642207; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 54642207 Bidet faucet
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>, Chrome
Pset_DistributionFlowElementCommon - Reference: 54642207 Bidet faucet; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 54642207(2026); Family and Type: 54642207(2026): 54642207 Bidet faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 54642207 Bidet faucet; Type Id: 32600; WarrantyStartDate: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0352361 m2; Volume: 0.00100131 m3
Identity Data - Mark: 14
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Phasing - Phase Created: New Construction
